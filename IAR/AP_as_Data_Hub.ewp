# IAR project AP_as_Data_Hub.ewp, settings and files
configuration CC1110-End Device (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC1110.i51
  ICC8051.CCDefines: MCU_H=<ioCC1110.h>; MRFI_CC1110
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: ..\..\..\Components\bsp; ..\..\..\Components\bsp\drivers; ..\..\..\Components\bsp\boards\sfrccxx10; ..\..\..\Components\mrfi; ..\..\..\Components\SimpliciTI\nwk; ..\..\..\Components\SimpliciTI\nwk_applications
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 1
  XLINK.XclFile: $TOOLKIT_DIR$\config\lnk51ew_cc1110.xcl
configuration CC1110-Access Point (8051, debug)
  as the first configuration, except:
  group Components/bsp
    ../../../Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Components/mrfi
    ../../../Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Components/nwk
    ../../../Components/simpliciti/nwk/: nwk.c nwk_api.c nwk_app.h nwk_frame.c nwk_globals.c nwk_QMgmt.c
    ../../../Components/SimpliciTI/nwk/: nwk.h nwk_api.h nwk_frame.h nwk_globals.h nwk_QMgmt.h nwk_types.h
  group Components/nwk applications
    ../../../Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_security.c nwk_security.h
  group peer applications/application/Access Point
    ../Applications/: main_AP_Async_Listen_autoack.c
  group peer applications/application/End Device
    ../../../Applications/: main_manyEDs.c main_manyEDs_autoack.c
  group peer applications/Configuration
    Configuration/: smpl_nwk_config.dat
  group peer applications/Configuration/Access Point
    Configuration/Access_Point/: smpl_config.dat
  group peer applications/Configuration/End Device
    Configuration/End_Device/: smpl_config.dat
  group peer applications/Configuration/Range Extender
    Configuration/Range_Extender/: smpl_config.dat
